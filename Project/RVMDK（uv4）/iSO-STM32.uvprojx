# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Alogrisem\inc;..\..\User\BSP_Init\inc;..\..\User\exDev\inc;..\..\FATFS\src;..\..\FATFS\SDIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
    ../../User/Alogrisem/src/: Control.c CRC.c CPGdemo.lib
    ../../User/BSP_Init/src/: bsp_adc.c bsp_led.c bsp_SysTick.c encode.c IOI2C.c timer.c uart.c can.c
    ../../User/exDev/src/: IMU.c init.c bsp_i2c_ee.c bsp_spi_flash.c
    ./: conmunication.c
  group FATFS
    ../../FATFS/src/: cc936.c diskio.c ff.c
    ../../FATFS/SDIO/: sdio_sdcard.c
